# The radio backend uses Foundation and Net only.
PACKAGECONFIG:raven = "Net"
PTEST_ENABLED:raven = "0"
