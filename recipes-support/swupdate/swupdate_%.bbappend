FILESEXTRAPATHS:prepend:raven := "${THISDIR}/files:"
SRC_URI:append:raven = " file://raven.cfg"
