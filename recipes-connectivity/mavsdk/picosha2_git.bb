SUMMARY = "Header-only SHA-256 implementation"
DESCRIPTION = "Provides the header-only SHA-256 implementation used by libmavlike"
HOMEPAGE = "https://github.com/julianoes/PicoSHA2"
BUGTRACKER = "https://github.com/julianoes/PicoSHA2/issues"
SECTION = "libs"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=277ac5bc231af240c801ade17211246a"
SRC_URI = "git://github.com/julianoes/PicoSHA2.git;protocol=https;branch=cmake-install-support"
SRCREV = "1bf940d8a03bb752604fbb366d47b97b50b9e6ce"
inherit cmake
ALLOW_EMPTY:${PN} = "1"
