SUMMARY = "YOLOv8 small detector for the i.MX95 Neutron NPU"
YOLO_SIZE = "s"
YOLO_MODEL_SHA256 = "24caeb02a65572a3ce8ba9f84f3d03ef6cffc40489c567db8c4ce6abd96f2090"

require yolov8-neutron.inc
