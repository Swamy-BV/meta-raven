SUMMARY = "YOLOv8 medium detector for the i.MX95 Neutron NPU"
YOLO_SIZE = "m"
YOLO_MODEL_SHA256 = "0e1a14c23c507390af8e67120fdb4e7dc1dbf95bff7e8b94543c1c1c03d1252f"

require yolov8-neutron.inc
