SUMMARY = "Raven FRDM-IMX95 Cortex-M7 PX4 firmware"
DESCRIPTION = "Builds and deploys the Raven M7 PX4 hardware bring-up firmware"
HOMEPAGE = "https://github.com/Swamy-BV/PX4-Autopilot"
BUGTRACKER = "https://github.com/Swamy-BV/PX4-Autopilot/issues"
SECTION = "bsp"

require raven-px4-firmware.inc
