# Use the SPDX identifier for the upstream three-clause BSD license.
# nooelint: oelint.append.protvars.LICENSE Correct generated metadata for Raven SPDX output.
LICENSE:raven = "BSD-3-Clause"
