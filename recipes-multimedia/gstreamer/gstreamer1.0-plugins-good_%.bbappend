# Portable software VP8 for media-capture; retain upstream plugin selections.
PACKAGECONFIG:append:raven = " vpx"
