# Enable the existing LLVM-matched upstream tool on the build host.
BBCLASSEXTEND:append:raven = " native"
